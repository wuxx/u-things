# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  BeforeMake: D:\20170809\1\pre_build.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\include;.\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./driver/gpio/: gpio.c
    ./driver/log/: log.c
    ./driver/uart/: uart.c
    ./driver/watchdog/: watchdog.c
    ./driver/shell/: shell.c
    ./system/: main.c int.c common.c
    ./driver/dma/: dma.c
    ./driver/flash/: flash.c
    ./driver/timer/: timer.c
    ./test/: systest.c test_dma.c test_flash.c test_gpio.c test_log.c test_timer.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
